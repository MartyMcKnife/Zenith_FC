<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Zenith_FC_v1.ewp</path>
  </project>
  <batchBuild />
</workspace>
